## hw/odp/Kconfig
```kconfig
config ODP_I2C_CONTROLLER
    bool

config ODP_I2C_TARGET
    bool

config ODP_GPIO
    bool

config ODP_PL061
    bool
```
